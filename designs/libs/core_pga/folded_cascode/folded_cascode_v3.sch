v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
P 4 1 1300 -960 {}
N 1870 -920 2190 -920 {lab=VDD3V3}
N 1870 -990 1870 -950 {lab=#net1}
N 1870 -990 2190 -990 {lab=#net1}
N 2190 -990 2190 -950 {lab=#net1}
N 2020 -1040 2020 -990 {lab=#net1}
N 2020 -1150 2020 -1100 {lab=VDD3V3}
N 1790 -920 1830 -920 {lab=inp}
N 2230 -920 2270 -920 {lab=inn}
N 2530 -1470 2530 -1410 {lab=VDD3V3}
N 2530 -1470 2780 -1470 {lab=VDD3V3}
N 2780 -1470 2780 -1410 {lab=VDD3V3}
N 2190 -890 2190 -810 {lab=#net2}
N 2190 -810 2780 -810 {lab=#net2}
N 1870 -890 1870 -730 {lab=#net3}
N 1870 -730 2530 -730 {lab=#net3}
N 2530 -740 2530 -670 {lab=#net3}
N 2530 -930 2530 -740 {lab=#net3}
N 2780 -820 2780 -670 {lab=#net2}
N 2780 -930 2780 -820 {lab=#net2}
N 2530 -520 2780 -520 {lab=VSS}
N 2530 -610 2530 -520 {lab=VSS}
N 2780 -610 2780 -520 {lab=VSS}
N 2020 -960 2020 -920 {lab=VDD3V3}
N 2660 -520 2660 -490 {lab=VSS}
N 2660 -1520 2660 -1470 {lab=VDD3V3}
N 2570 -640 2740 -640 {lab=Vbsnk}
N 2660 -640 2660 -600 {lab=Vbsnk}
N 2420 -960 2530 -960 {lab=VSS}
N 2780 -960 2900 -960 {lab=VSS}
N 2420 -960 2420 -530 {lab=VSS}
N 2420 -530 2420 -520 {lab=VSS}
N 2420 -520 2530 -520 {lab=VSS}
N 2900 -960 2900 -520 {lab=VSS}
N 2780 -520 2900 -520 {lab=VSS}
N 2570 -960 2740 -960 {lab=Vb0V94}
N 2660 -960 2660 -920 {lab=Vb0V94}
N 2780 -1120 2780 -990 {lab=outp}
N 2530 -1120 2530 -990 {lab=#net4}
N 2570 -1150 2740 -1150 {lab=Vb1V3}
N 2660 -1150 2660 -1080 {lab=Vb1V3}
N 2530 -1280 2530 -1180 {lab=#net5}
N 2780 -1280 2780 -1180 {lab=#net6}
N 2450 -1470 2450 -1310 {lab=VDD3V3}
N 2450 -1470 2530 -1470 {lab=VDD3V3}
N 2450 -1310 2450 -1150 {lab=VDD3V3}
N 2450 -1150 2530 -1150 {lab=VDD3V3}
N 2860 -1470 2860 -1310 {lab=VDD3V3}
N 2860 -1310 2860 -1150 {lab=VDD3V3}
N 2780 -1150 2860 -1150 {lab=VDD3V3}
N 2780 -1470 2860 -1470 {lab=VDD3V3}
N 2500 -1040 2530 -1040 {lab=#net4}
N 2780 -1040 2820 -1040 {lab=outp}
N 2530 -1410 2530 -1340 {lab=VDD3V3}
N 2780 -1410 2780 -1340 {lab=VDD3V3}
N 1950 -1070 1980 -1070 {lab=Vbtail}
N 2020 -1100 2020 -1070 {lab=VDD3V3}
N 2530 -640 2530 -610 {lab=VSS}
N 2780 -640 2780 -610 {lab=VSS}
N 2780 -1310 2860 -1310 {lab=VDD3V3}
N 2450 -1310 2530 -1310 {lab=VDD3V3}
N 2570 -1310 2740 -1310 {lab=Vbfb}
N 2660 -1310 2660 -1270 {lab=Vbfb}
N 3460 -1070 3460 -1010 {lab=#net7}
N 3460 -1010 3740 -1010 {lab=#net7}
N 3740 -1070 3740 -1010 {lab=#net7}
N 3360 -1100 3420 -1100 {lab=outp}
N 3600 -810 3600 -750 {lab=VSS}
N 3600 -840 3620 -840 {lab=VSS}
N 4020 -1070 4020 -1010 {lab=#net8}
N 4020 -1010 4300 -1010 {lab=#net8}
N 4300 -1070 4300 -1010 {lab=#net8}
N 4160 -810 4160 -750 {lab=VSS}
N 4160 -840 4180 -840 {lab=VSS}
N 3620 -840 3620 -750 {lab=VSS}
N 4180 -840 4180 -750 {lab=VSS}
N 4340 -1100 4400 -1100 {lab=outn}
N 3460 -1250 3460 -1130 {lab=#net9}
N 4300 -1190 4300 -1130 {lab=#net10}
N 3460 -1100 3520 -1100 {lab=VSS}
N 3680 -1100 3740 -1100 {lab=VSS}
N 4020 -1100 4080 -1100 {lab=VSS}
N 3360 -840 3560 -840 {lab=Ib}
N 3320 -810 3320 -750 {lab=VSS}
N 3300 -840 3320 -840 {lab=VSS}
N 3300 -840 3300 -750 {lab=VSS}
N 3240 -750 4180 -750 {lab=VSS}
N 3320 -910 3420 -910 {lab=Ib}
N 3420 -910 3420 -840 {lab=Ib}
N 3420 -910 4060 -910 {lab=Ib}
N 3600 -1010 3600 -870 {lab=#net7}
N 4160 -1010 4160 -870 {lab=#net8}
N 4060 -910 4060 -840 {lab=Ib}
N 4060 -840 4120 -840 {lab=Ib}
N 3320 -970 3320 -870 {lab=Ib}
N 3380 -1410 4020 -1410 {lab=VDD3V3}
N 3520 -1100 3680 -1100 {lab=VSS}
N 3950 -1100 3980 -1100 {lab=Vcm}
N 920 -1050 920 -990 {lab=1ua}
N 920 -930 920 -880 {lab=VSS}
N 920 -1020 990 -1020 {lab=1ua}
N 990 -1020 990 -960 {lab=1ua}
N 960 -960 990 -960 {lab=1ua}
N 990 -960 1090 -960 {lab=1ua}
N 920 -960 920 -930 {lab=VSS}
N 1130 -960 1130 -930 {lab=VSS}
N 1130 -1040 1130 -990 {lab=Vbtail}
N 1130 -1180 1130 -1100 {lab=VDD3V3}
N 920 -880 1130 -880 {lab=VSS}
N 1130 -930 1130 -880 {lab=VSS}
N 1130 -1020 1210 -1020 {lab=Vbtail}
N 1210 -1070 1210 -1020 {lab=Vbtail}
N 1170 -1070 1210 -1070 {lab=Vbtail}
N 1130 -1100 1130 -1070 {lab=VDD3V3}
N 1380 -960 1380 -930 {lab=VSS}
N 1380 -930 1380 -880 {lab=VSS}
N 1380 -1100 1380 -1070 {lab=VDD3V3}
N 1130 -1180 1380 -1180 {lab=VDD3V3}
N 1130 -880 1380 -880 {lab=VSS}
N 1210 -1070 1340 -1070 {lab=Vbtail}
N 1380 -1040 1380 -990 {lab=Vbsnk}
N 1380 -1180 1380 -1100 {lab=VDD3V3}
N 1300 -960 1340 -960 {lab=Vbsnk}
N 1300 -1020 1300 -960 {lab=Vbsnk}
N 1300 -1020 1380 -1020 {lab=Vbsnk}
N 3740 -1200 3740 -1130 {lab=Vbfb}
N 3740 -1200 4020 -1200 {lab=Vbfb}
N 4020 -1200 4020 -1130 {lab=Vbfb}
N 3780 -1100 3950 -1100 {lab=Vcm}
N 3890 -1100 3890 -1070 {lab=Vcm}
N 3460 -1290 3460 -1250 {lab=#net9}
N 3460 -1410 3460 -1350 {lab=VDD3V3}
N 3380 -1320 3420 -1320 {lab=#net9}
N 3380 -1320 3380 -1270 {lab=#net9}
N 3380 -1270 3460 -1270 {lab=#net9}
N 4220 -1340 4260 -1340 {lab=#net10}
N 4220 -1340 4220 -1290 {lab=#net10}
N 4220 -1290 4300 -1290 {lab=#net10}
N 4300 -1310 4300 -1190 {lab=#net10}
N 4020 -1410 4300 -1410 {lab=VDD3V3}
N 4300 -1410 4300 -1370 {lab=VDD3V3}
N 3890 -1290 3890 -1250 {lab=Vbfb}
N 3810 -1320 3850 -1320 {lab=Vbfb}
N 3810 -1320 3810 -1270 {lab=Vbfb}
N 3810 -1270 3890 -1270 {lab=Vbfb}
N 3890 -1410 3890 -1350 {lab=VDD3V3}
N 3890 -1250 3890 -1200 {lab=Vbfb}
N 1040 -960 1040 -940 {lab=1ua}
N 1380 -1180 1590 -1180 {lab=VDD3V3}
N 1590 -1180 1590 -1100 {lab=VDD3V3}
N 1510 -1070 1550 -1070 {lab=Vbtail}
N 1590 -1040 1590 -970 {lab=Ib}
N 1590 -1100 1590 -1070 {lab=VDD3V3}
N 4080 -1100 4300 -1100 {lab=VSS}
N 4300 -1370 4300 -1340 {lab=VDD3V3}
N 3890 -1350 3890 -1320 {lab=VDD3V3}
N 3460 -1350 3460 -1320 {lab=VDD3V3}
N 310 -1140 370 -1140 {lab=outp}
N 310 -1100 370 -1100 {lab=outn}
N 320 -1050 380 -1050 {lab=VSS}
N 310 -1050 320 -1050 {lab=VSS}
N 320 -1010 380 -1010 {lab=VDD3V3}
N 310 -1010 320 -1010 {lab=VDD3V3}
N 310 -960 370 -960 {lab=inp}
N 310 -920 370 -920 {lab=inn}
N 310 -880 370 -880 {lab=1ua}
N 310 -840 370 -840 {lab=Vb1V3}
N 310 -800 370 -800 {lab=Vb0V94}
N 310 -760 370 -760 {lab=Vcm}
C {symbols/pfet_03v3.sym} 1850 -920 0 0 {name=M1
L=1u
W=10u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2020 -960 0 0 {name=p2 sig_type=std_logic lab=VDD3V3}
C {lab_pin.sym} 2020 -1150 0 0 {name=p1 sig_type=std_logic lab=VDD3V3}
C {lab_pin.sym} 2660 -1520 0 0 {name=p6 sig_type=std_logic lab=VDD3V3}
C {symbols/pfet_03v3.sym} 2210 -920 0 1 {name=M2
L=1u
W=10u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2550 -960 0 1 {name=M6
L=1u
W=4u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2760 -960 0 0 {name=M7
L=1u
W=4u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2550 -1150 0 1 {name=M8
L=1u
W=4u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2760 -1150 0 0 {name=M9
L=1u
W=4u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2000 -1070 0 0 {name=M3
L=1u
W=32u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1950 -1070 0 0 {name=p8 sig_type=std_logic lab=Vbtail}
C {symbols/nfet_03v3.sym} 2550 -640 0 1 {name=M4
L=1u
W=9u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2760 -640 0 0 {name=M5
L=1u
W=9u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2550 -1310 0 1 {name=M10
L=1u
W=4u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2760 -1310 0 0 {name=M11
L=1u
W=4u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2660 -1270 0 0 {name=p25 sig_type=std_logic lab=Vbfb}
C {lab_pin.sym} 2660 -600 0 0 {name=p11 sig_type=std_logic lab=Vbsnk}
C {lab_pin.sym} 3320 -970 0 0 {name=p31 sig_type=std_logic lab=Ib}
C {lab_pin.sym} 3380 -1410 0 0 {name=p18 sig_type=std_logic lab=VDD3V3}
C {symbols/pfet_03v3.sym} 3440 -1320 0 0 {name=M20
L=1u
W=3u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3440 -1100 0 0 {name=M21
L=1u
W=10u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3760 -1100 0 1 {name=M22
L=1u
W=10u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3580 -840 0 0 {name=M23
L=1u
W=8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4000 -1100 0 0 {name=M24
L=1u
W=10u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4320 -1100 0 1 {name=M25
L=1u
W=10u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4140 -840 0 0 {name=M26
L=1u
W=8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3600 -1100 0 1 {name=p28 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4150 -1100 0 0 {name=p36 sig_type=std_logic lab=VSS}
C {symbols/nfet_03v3.sym} 3340 -840 0 1 {name=M27
L=1u
W=8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3890 -1070 0 0 {name=p17 sig_type=std_logic lab=Vcm}
C {symbols/nfet_03v3.sym} 940 -960 0 1 {name=M12
L=1u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1110 -960 0 0 {name=M13
L=1u
W=3u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1150 -1070 0 1 {name=M14
L=1u
W=6u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1260 -1070 1 1 {name=p35 sig_type=std_logic lab=Vbtail}
C {symbols/nfet_03v3.sym} 1360 -960 0 0 {name=M15
L=1u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1360 -1070 0 0 {name=M16
L=1u
W=11u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1300 -960 0 0 {name=p27 sig_type=std_logic lab=Vbsnk}
C {lab_pin.sym} 3810 -1320 0 0 {name=p13 sig_type=std_logic lab=Vbfb}
C {symbols/pfet_03v3.sym} 4280 -1340 0 0 {name=M17
L=1u
W=3u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3870 -1320 0 0 {name=M18
L=1u
W=3u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1570 -1070 0 0 {name=M28
L=1u
W=4.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1510 -1070 1 1 {name=p26 sig_type=std_logic lab=Vbtail}
C {lab_pin.sym} 1590 -970 0 0 {name=p37 sig_type=std_logic lab=Ib}
C {lab_wire.sym} 3240 -750 0 0 {name=p33 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2660 -490 0 1 {name=p34 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 920 -880 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {opin.sym} 370 -1140 0 0 {name=p44 lab=outp}
C {lab_pin.sym} 310 -1140 0 0 {name=p45 sig_type=std_logic lab=outp}
C {opin.sym} 370 -1100 0 0 {name=p46 lab=outn}
C {lab_pin.sym} 310 -1100 0 0 {name=p47 sig_type=std_logic lab=outn}
C {iopin.sym} 380 -1050 0 0 {name=p48 lab=VSS}
C {lab_wire.sym} 310 -1050 0 0 {name=p49 sig_type=std_logic lab=VSS}
C {iopin.sym} 380 -1010 0 0 {name=p50 lab=VDD3V3}
C {lab_pin.sym} 310 -1010 0 0 {name=p51 sig_type=std_logic lab=VDD3V3}
C {ipin.sym} 310 -960 0 0 {name=p5 lab=inp}
C {ipin.sym} 310 -920 0 0 {name=p10 lab=inn}
C {lab_pin.sym} 370 -960 0 1 {name=p15 sig_type=std_logic lab=inp}
C {lab_pin.sym} 370 -920 0 1 {name=p21 sig_type=std_logic lab=inn}
C {lab_pin.sym} 920 -1050 0 1 {name=p38 sig_type=std_logic lab=1ua}
C {lab_pin.sym} 310 -880 0 0 {name=p30 sig_type=std_logic lab=1ua}
C {iopin.sym} 370 -880 0 0 {name=p42 lab=1ua}
C {lab_pin.sym} 310 -840 0 0 {name=p22 sig_type=std_logic lab=Vb1V3}
C {lab_pin.sym} 310 -800 0 0 {name=p52 sig_type=std_logic lab=Vb0V94}
C {iopin.sym} 370 -840 0 0 {name=p53 lab=Vb1V3}
C {iopin.sym} 370 -800 0 0 {name=p54 lab=Vb0V94}
C {lab_pin.sym} 1790 -920 0 0 {name=p12 sig_type=std_logic lab=inp}
C {lab_pin.sym} 2270 -920 0 1 {name=p14 sig_type=std_logic lab=inn}
C {lab_pin.sym} 2660 -1080 0 0 {name=p4 sig_type=std_logic lab=Vb1V3}
C {lab_pin.sym} 2660 -920 0 0 {name=p16 sig_type=std_logic lab=Vb0V94}
C {lab_pin.sym} 310 -760 0 0 {name=p19 sig_type=std_logic lab=Vcm}
C {iopin.sym} 370 -760 0 0 {name=p24 lab=Vcm}
C {lab_pin.sym} 4400 -1100 0 1 {name=p58 sig_type=std_logic lab=outn}
C {lab_pin.sym} 3360 -1100 0 0 {name=p32 sig_type=std_logic lab=outp}
C {lab_pin.sym} 1130 -1180 0 0 {name=p40 sig_type=std_logic lab=VDD3V3}
C {lab_pin.sym} 2820 -1040 0 1 {name=p23 sig_type=std_logic lab=outp}
C {lab_pin.sym} 2500 -1040 0 0 {name=p7 sig_type=std_logic lab=outn}
