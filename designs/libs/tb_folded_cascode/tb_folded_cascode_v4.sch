v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
P 4 1 1000 -1350 {}
P 4 1 980 -1800 {}
N 2170 -600 2490 -600 {lab=VDD3V3}
N 2170 -670 2170 -630 {lab=#net1}
N 2170 -670 2490 -670 {lab=#net1}
N 2490 -670 2490 -630 {lab=#net1}
N 2320 -720 2320 -670 {lab=#net1}
N 2320 -830 2320 -780 {lab=VDD3V3}
N 2090 -600 2130 -600 {lab=vp}
N 2530 -600 2570 -600 {lab=vn}
N 2830 -1150 2830 -1090 {lab=VDD3V3}
N 2830 -1150 3080 -1150 {lab=VDD3V3}
N 3080 -1150 3080 -1090 {lab=VDD3V3}
N 2490 -570 2490 -490 {lab=#net2}
N 2490 -490 3080 -490 {lab=#net2}
N 2170 -570 2170 -410 {lab=#net3}
N 2170 -410 2830 -410 {lab=#net3}
N 2830 -420 2830 -350 {lab=#net3}
N 2830 -610 2830 -420 {lab=#net3}
N 3080 -500 3080 -350 {lab=#net2}
N 3080 -610 3080 -500 {lab=#net2}
N 2830 -200 3080 -200 {lab=VSS}
N 2830 -290 2830 -200 {lab=VSS}
N 3080 -290 3080 -200 {lab=VSS}
N 2320 -640 2320 -600 {lab=VDD3V3}
N 890 -900 890 -860 {lab=VSS}
N 890 -1020 890 -960 {lab=VDD3V3}
N 2960 -200 2960 -170 {lab=VSS}
N 2960 -1200 2960 -1150 {lab=VDD3V3}
N 2870 -320 3040 -320 {lab=Vbsnk}
N 2960 -320 2960 -280 {lab=Vbsnk}
N 2720 -640 2830 -640 {lab=VSS}
N 3080 -640 3200 -640 {lab=VSS}
N 2720 -640 2720 -210 {lab=VSS}
N 2720 -210 2720 -200 {lab=VSS}
N 2720 -200 2830 -200 {lab=VSS}
N 3200 -640 3200 -200 {lab=VSS}
N 3080 -200 3200 -200 {lab=VSS}
N 2870 -640 3040 -640 {lab=Vbcascn}
N 2960 -640 2960 -600 {lab=Vbcascn}
N 1650 -1350 1650 -1310 {lab=VSS}
N 1650 -1470 1650 -1410 {lab=Vbcascn}
N 3080 -800 3080 -670 {lab=voutp}
N 2830 -800 2830 -670 {lab=voutn}
N 2870 -830 3040 -830 {lab=Vbcascp}
N 2960 -830 2960 -760 {lab=Vbcascp}
N 2830 -960 2830 -860 {lab=#net4}
N 3080 -960 3080 -860 {lab=#net5}
N 2750 -1150 2750 -990 {lab=VDD3V3}
N 2750 -1150 2830 -1150 {lab=VDD3V3}
N 2750 -990 2750 -830 {lab=VDD3V3}
N 2750 -830 2830 -830 {lab=VDD3V3}
N 3160 -1150 3160 -990 {lab=VDD3V3}
N 3160 -990 3160 -830 {lab=VDD3V3}
N 3080 -830 3160 -830 {lab=VDD3V3}
N 3080 -1150 3160 -1150 {lab=VDD3V3}
N 2800 -720 2830 -720 {lab=voutn}
N 3080 -720 3120 -720 {lab=voutp}
N 1490 -1350 1490 -1310 {lab=VSS}
N 1490 -1470 1490 -1410 {lab=Vbcascp}
N 1270 -970 1270 -930 {lab=Vref}
N 1270 -1090 1270 -1030 {lab=vp}
N 1410 -970 1410 -930 {lab=Vref}
N 1410 -1090 1410 -1030 {lab=vn}
N 1340 -870 1340 -830 {lab=VSS}
N 1270 -930 1410 -930 {lab=Vref}
N 2830 -1090 2830 -1020 {lab=VDD3V3}
N 3080 -1090 3080 -1020 {lab=VDD3V3}
N 2250 -750 2280 -750 {lab=Vbtail}
N 2320 -780 2320 -750 {lab=VDD3V3}
N 2830 -320 2830 -290 {lab=VSS}
N 3080 -320 3080 -290 {lab=VSS}
N 3080 -990 3160 -990 {lab=VDD3V3}
N 2750 -990 2830 -990 {lab=VDD3V3}
N 2870 -990 3040 -990 {lab=Vbfb}
N 2960 -990 2960 -950 {lab=Vbfb}
N 1190 -930 1270 -930 {lab=Vref}
N 2480 -1710 2480 -1650 {lab=#net6}
N 2480 -1650 2760 -1650 {lab=#net6}
N 2760 -1710 2760 -1650 {lab=#net6}
N 2380 -1740 2440 -1740 {lab=voutp}
N 2620 -1450 2620 -1390 {lab=VSS}
N 2620 -1480 2640 -1480 {lab=VSS}
N 3040 -1710 3040 -1650 {lab=#net7}
N 3040 -1650 3320 -1650 {lab=#net7}
N 3320 -1710 3320 -1650 {lab=#net7}
N 3180 -1450 3180 -1390 {lab=VSS}
N 3180 -1480 3200 -1480 {lab=VSS}
N 2640 -1480 2640 -1390 {lab=VSS}
N 3200 -1480 3200 -1390 {lab=VSS}
N 3360 -1740 3420 -1740 {lab=voutn}
N 2480 -1890 2480 -1770 {lab=#net8}
N 3320 -1830 3320 -1770 {lab=#net9}
N 2480 -1740 2540 -1740 {lab=VSS}
N 2700 -1740 2760 -1740 {lab=VSS}
N 3040 -1740 3100 -1740 {lab=VSS}
N 2380 -1480 2580 -1480 {lab=Ib}
N 2340 -1450 2340 -1390 {lab=VSS}
N 2320 -1480 2340 -1480 {lab=VSS}
N 2320 -1480 2320 -1390 {lab=VSS}
N 2260 -1390 3200 -1390 {lab=VSS}
N 2340 -1550 2440 -1550 {lab=Ib}
N 2440 -1550 2440 -1480 {lab=Ib}
N 2440 -1550 3080 -1550 {lab=Ib}
N 2620 -1650 2620 -1510 {lab=#net6}
N 3180 -1650 3180 -1510 {lab=#net7}
N 3080 -1550 3080 -1480 {lab=Ib}
N 3080 -1480 3140 -1480 {lab=Ib}
N 2340 -1610 2340 -1510 {lab=Ib}
N 2400 -2050 3040 -2050 {lab=VDD3V3}
N 1020 -900 1020 -860 {lab=0}
N 1020 -1020 1020 -960 {lab=VSS}
N 2540 -1740 2700 -1740 {lab=VSS}
N 2970 -1740 3000 -1740 {lab=Vref}
N 620 -1570 620 -1500 {lab=VDD3V3}
N 620 -1440 620 -1380 {lab=#net10}
N 620 -1320 620 -1270 {lab=VSS}
N 620 -1410 690 -1410 {lab=#net10}
N 690 -1410 690 -1350 {lab=#net10}
N 660 -1350 690 -1350 {lab=#net10}
N 690 -1350 790 -1350 {lab=#net10}
N 620 -1350 620 -1320 {lab=VSS}
N 830 -1350 830 -1320 {lab=VSS}
N 830 -1430 830 -1380 {lab=#net11}
N 620 -1570 830 -1570 {lab=VDD3V3}
N 830 -1570 830 -1490 {lab=VDD3V3}
N 620 -1270 830 -1270 {lab=VSS}
N 830 -1320 830 -1270 {lab=VSS}
N 830 -1410 910 -1410 {lab=#net11}
N 910 -1460 910 -1410 {lab=#net11}
N 870 -1460 910 -1460 {lab=#net11}
N 830 -1490 830 -1460 {lab=VDD3V3}
N 1080 -1350 1080 -1320 {lab=VSS}
N 1080 -1320 1080 -1270 {lab=VSS}
N 1080 -1490 1080 -1460 {lab=VDD3V3}
N 830 -1570 1080 -1570 {lab=VDD3V3}
N 830 -1270 1080 -1270 {lab=VSS}
N 910 -1460 1040 -1460 {lab=#net11}
N 1080 -1430 1080 -1380 {lab=#net12}
N 1080 -1570 1080 -1490 {lab=VDD3V3}
N 1000 -1350 1040 -1350 {lab=#net12}
N 1000 -1410 1000 -1350 {lab=#net12}
N 1000 -1410 1080 -1410 {lab=#net12}
N 2760 -1840 2760 -1770 {lab=Vbfb}
N 2760 -1840 3040 -1840 {lab=Vbfb}
N 3040 -1840 3040 -1770 {lab=Vbfb}
N 2800 -1740 2970 -1740 {lab=Vref}
N 2910 -1740 2910 -1710 {lab=Vref}
N 2480 -1930 2480 -1890 {lab=#net8}
N 2480 -2050 2480 -1990 {lab=VDD3V3}
N 2400 -1960 2440 -1960 {lab=#net8}
N 2400 -1960 2400 -1910 {lab=#net8}
N 2400 -1910 2480 -1910 {lab=#net8}
N 3240 -1980 3280 -1980 {lab=#net9}
N 3240 -1980 3240 -1930 {lab=#net9}
N 3240 -1930 3320 -1930 {lab=#net9}
N 3320 -1950 3320 -1830 {lab=#net9}
N 3040 -2050 3320 -2050 {lab=VDD3V3}
N 3320 -2050 3320 -2010 {lab=VDD3V3}
N 2910 -1930 2910 -1890 {lab=Vbfb}
N 2830 -1960 2870 -1960 {lab=Vbfb}
N 2830 -1960 2830 -1910 {lab=Vbfb}
N 2830 -1910 2910 -1910 {lab=Vbfb}
N 2910 -2050 2910 -1990 {lab=VDD3V3}
N 2910 -1890 2910 -1840 {lab=Vbfb}
N 740 -1350 740 -1330 {lab=#net10}
N 1080 -1570 1290 -1570 {lab=VDD3V3}
N 1290 -1570 1290 -1490 {lab=VDD3V3}
N 1210 -1460 1250 -1460 {lab=#net13}
N 1290 -1430 1290 -1360 {lab=#net14}
N 3490 -800 3490 -780 {lab=voutp_buff}
N 3580 -800 3580 -780 {lab=voutn_buff}
N 3490 -720 3490 -680 {lab=VSS}
N 3490 -680 3580 -680 {lab=VSS}
N 3580 -730 3580 -680 {lab=VSS}
N 3540 -680 3540 -660 {lab=VSS}
N 1290 -1490 1290 -1460 {lab=VDD3V3}
N 3100 -1740 3320 -1740 {lab=VSS}
N 3320 -2010 3320 -1980 {lab=VDD3V3}
N 2910 -1990 2910 -1960 {lab=VDD3V3}
N 2480 -1990 2480 -1960 {lab=VDD3V3}
N 4310 -1760 4310 -1720 {lab=VSS}
N 4310 -1880 4310 -1820 {lab=Vb_ota}
N 5170 -1050 5170 -1000 {lab=VDD3V3}
N 5170 -1050 5410 -1050 {lab=VDD3V3}
N 5410 -1050 5410 -1000 {lab=VDD3V3}
N 5210 -970 5370 -970 {lab=#net15}
N 5170 -1000 5170 -970 {lab=VDD3V3}
N 5410 -1000 5410 -970 {lab=VDD3V3}
N 5170 -940 5170 -850 {lab=#net15}
N 5410 -940 5410 -860 {lab=#net16}
N 5410 -860 5410 -850 {lab=#net16}
N 5170 -910 5270 -910 {lab=#net15}
N 5270 -970 5270 -910 {lab=#net15}
N 5090 -820 5130 -820 {lab=#net17}
N 5450 -820 5500 -820 {lab=#net16}
N 5170 -790 5170 -740 {lab=#net18}
N 5170 -740 5410 -740 {lab=#net18}
N 5410 -790 5410 -740 {lab=#net18}
N 5290 -1090 5290 -1050 {lab=VDD3V3}
N 5300 -740 5300 -710 {lab=#net18}
N 5300 -650 5300 -620 {lab=VSS}
N 5410 -900 5500 -900 {lab=#net16}
N 5500 -900 5500 -820 {lab=#net16}
N 5500 -900 5560 -900 {lab=#net16}
N 5970 -1040 5970 -990 {lab=VDD3V3}
N 5970 -1040 6210 -1040 {lab=VDD3V3}
N 6210 -1040 6210 -990 {lab=VDD3V3}
N 6010 -960 6170 -960 {lab=#net19}
N 5970 -990 5970 -960 {lab=VDD3V3}
N 6210 -990 6210 -960 {lab=VDD3V3}
N 5970 -930 5970 -840 {lab=#net19}
N 6210 -930 6210 -850 {lab=#net20}
N 6210 -850 6210 -840 {lab=#net20}
N 5970 -900 6070 -900 {lab=#net19}
N 6070 -960 6070 -900 {lab=#net19}
N 5890 -810 5930 -810 {lab=#net21}
N 6250 -810 6300 -810 {lab=#net20}
N 5970 -780 5970 -730 {lab=#net22}
N 5970 -730 6210 -730 {lab=#net22}
N 6210 -780 6210 -730 {lab=#net22}
N 6090 -1080 6090 -1040 {lab=VDD3V3}
N 6100 -730 6100 -700 {lab=#net22}
N 6100 -640 6100 -610 {lab=VSS}
N 6210 -890 6300 -890 {lab=#net20}
N 6300 -890 6300 -810 {lab=#net20}
N 6300 -890 6360 -890 {lab=#net20}
N 5970 -810 6210 -810 {lab=VSS}
N 6100 -830 6100 -810 {lab=VSS}
N 5170 -820 5410 -820 {lab=VSS}
N 5300 -850 5300 -820 {lab=VSS}
N 600 -2020 600 -1950 {lab=VDD3V3}
N 600 -1890 600 -1830 {lab=Vbias}
N 600 -1770 600 -1720 {lab=VSS}
N 600 -1860 670 -1860 {lab=Vbias}
N 670 -1860 670 -1800 {lab=Vbias}
N 640 -1800 670 -1800 {lab=Vbias}
N 670 -1800 770 -1800 {lab=Vbias}
N 600 -1800 600 -1770 {lab=VSS}
N 810 -1800 810 -1770 {lab=VSS}
N 810 -1880 810 -1830 {lab=Vbtail}
N 600 -2020 810 -2020 {lab=VDD3V3}
N 810 -2020 810 -1940 {lab=VDD3V3}
N 600 -1720 810 -1720 {lab=VSS}
N 810 -1770 810 -1720 {lab=VSS}
N 810 -1860 890 -1860 {lab=Vbtail}
N 890 -1910 890 -1860 {lab=Vbtail}
N 850 -1910 890 -1910 {lab=Vbtail}
N 810 -1940 810 -1910 {lab=VDD3V3}
N 1060 -1800 1060 -1770 {lab=VSS}
N 1060 -1770 1060 -1720 {lab=VSS}
N 1060 -1940 1060 -1910 {lab=VDD3V3}
N 810 -2020 1060 -2020 {lab=VDD3V3}
N 810 -1720 1060 -1720 {lab=VSS}
N 890 -1910 1020 -1910 {lab=Vbtail}
N 1060 -1880 1060 -1830 {lab=Vbsnk}
N 1060 -2020 1060 -1940 {lab=VDD3V3}
N 980 -1800 1020 -1800 {lab=Vbsnk}
N 980 -1860 980 -1800 {lab=Vbsnk}
N 980 -1860 1060 -1860 {lab=Vbsnk}
N 720 -1800 720 -1780 {lab=Vbias}
N 1060 -2020 1270 -2020 {lab=VDD3V3}
N 1270 -2020 1270 -1940 {lab=VDD3V3}
N 1190 -1910 1230 -1910 {lab=Vbtail}
N 1270 -1880 1270 -1810 {lab=Ib}
N 1270 -1940 1270 -1910 {lab=VDD3V3}
N 5170 -1800 5170 -1750 {lab=VDD3V3}
N 5170 -1800 5410 -1800 {lab=VDD3V3}
N 5410 -1800 5410 -1750 {lab=VDD3V3}
N 5210 -1720 5370 -1720 {lab=#net23}
N 5170 -1750 5170 -1720 {lab=VDD3V3}
N 5410 -1750 5410 -1720 {lab=VDD3V3}
N 5170 -1690 5170 -1600 {lab=#net23}
N 5410 -1690 5410 -1610 {lab=voutp_buff}
N 5410 -1610 5410 -1600 {lab=voutp_buff}
N 5170 -1660 5270 -1660 {lab=#net23}
N 5270 -1720 5270 -1660 {lab=#net23}
N 5090 -1570 5130 -1570 {lab=voutp}
N 5450 -1570 5500 -1570 {lab=voutp_buff}
N 5170 -1540 5170 -1490 {lab=#net24}
N 5170 -1490 5410 -1490 {lab=#net24}
N 5410 -1540 5410 -1490 {lab=#net24}
N 5290 -1840 5290 -1800 {lab=VDD3V3}
N 5300 -1490 5300 -1460 {lab=#net24}
N 5300 -1400 5300 -1370 {lab=VSS}
N 5410 -1650 5500 -1650 {lab=voutp_buff}
N 5500 -1650 5500 -1570 {lab=voutp_buff}
N 5500 -1650 5560 -1650 {lab=voutp_buff}
N 5170 -1570 5410 -1570 {lab=VSS}
N 5300 -1600 5300 -1570 {lab=VSS}
N 5200 -1430 5260 -1430 {lab=Vbias}
N 5930 -1790 5930 -1740 {lab=VDD3V3}
N 5930 -1790 6170 -1790 {lab=VDD3V3}
N 6170 -1790 6170 -1740 {lab=VDD3V3}
N 5970 -1710 6130 -1710 {lab=#net25}
N 5930 -1740 5930 -1710 {lab=VDD3V3}
N 6170 -1740 6170 -1710 {lab=VDD3V3}
N 5930 -1680 5930 -1590 {lab=#net25}
N 6170 -1680 6170 -1600 {lab=voutn_buff}
N 6170 -1600 6170 -1590 {lab=voutn_buff}
N 5930 -1650 6030 -1650 {lab=#net25}
N 6030 -1710 6030 -1650 {lab=#net25}
N 5850 -1560 5890 -1560 {lab=voutn}
N 6210 -1560 6260 -1560 {lab=voutn_buff}
N 5930 -1530 5930 -1480 {lab=#net26}
N 5930 -1480 6170 -1480 {lab=#net26}
N 6170 -1530 6170 -1480 {lab=#net26}
N 6050 -1830 6050 -1790 {lab=VDD3V3}
N 6060 -1480 6060 -1450 {lab=#net26}
N 6060 -1390 6060 -1360 {lab=VSS}
N 6170 -1640 6260 -1640 {lab=voutn_buff}
N 6260 -1640 6260 -1560 {lab=voutn_buff}
N 6260 -1640 6320 -1640 {lab=voutn_buff}
N 5930 -1560 6170 -1560 {lab=VSS}
N 6060 -1590 6060 -1560 {lab=VSS}
N 5960 -1420 6020 -1420 {lab=Vbias}
N 7390 -1800 7390 -1750 {lab=VDD3V3}
N 7390 -1800 7630 -1800 {lab=VDD3V3}
N 7630 -1800 7630 -1750 {lab=VDD3V3}
N 7430 -1720 7590 -1720 {lab=#net27}
N 7390 -1750 7390 -1720 {lab=VDD3V3}
N 7630 -1750 7630 -1720 {lab=VDD3V3}
N 7390 -1690 7390 -1600 {lab=#net27}
N 7630 -1690 7630 -1610 {lab=vout_tran}
N 7630 -1610 7630 -1600 {lab=vout_tran}
N 7390 -1660 7490 -1660 {lab=#net27}
N 7490 -1720 7490 -1660 {lab=#net27}
N 7310 -1570 7350 -1570 {lab=vin_tran}
N 7670 -1570 7720 -1570 {lab=vout_tran}
N 7390 -1540 7390 -1490 {lab=#net28}
N 7390 -1490 7630 -1490 {lab=#net28}
N 7630 -1540 7630 -1490 {lab=#net28}
N 7510 -1840 7510 -1800 {lab=VDD3V3}
N 7520 -1490 7520 -1460 {lab=#net28}
N 7520 -1400 7520 -1370 {lab=VSS}
N 7630 -1650 7720 -1650 {lab=vout_tran}
N 7720 -1650 7720 -1570 {lab=vout_tran}
N 7720 -1650 7780 -1650 {lab=vout_tran}
N 7390 -1570 7630 -1570 {lab=VSS}
N 7520 -1600 7520 -1570 {lab=VSS}
N 7420 -1430 7480 -1430 {lab=Vbias}
N 6930 -1450 6930 -1410 {lab=VSS}
N 6930 -1570 6930 -1510 {lab=vin_tran}
N 7520 -1430 7520 -1400 {lab=VSS}
N 6060 -1420 6060 -1390 {lab=VSS}
N 5300 -1430 5300 -1400 {lab=VSS}
N 1270 -620 1270 -580 {lab=VSS}
N 1270 -740 1270 -680 {lab=#net29}
N 1410 -620 1410 -580 {lab=VSS}
N 1410 -740 1410 -680 {lab=#net30}
N 1270 -580 1410 -580 {lab=VSS}
N 1340 -580 1340 -540 {lab=VSS}
C {symbols/pfet_03v3.sym} 2150 -600 0 0 {name=M1
L=1u
W=10u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2320 -640 0 0 {name=p2 sig_type=std_logic lab=VDD3V3}
C {lab_pin.sym} 2320 -830 0 0 {name=p1 sig_type=std_logic lab=VDD3V3}
C {lab_pin.sym} 2570 -600 0 1 {name=p4 sig_type=std_logic lab=vn}
C {vsource.sym} 890 -930 0 0 {name=V1 value=3.3 savecurrent=false}
C {lab_pin.sym} 890 -1020 0 0 {name=p5 sig_type=std_logic lab=VDD3V3}
C {lab_pin.sym} 2960 -1200 0 0 {name=p6 sig_type=std_logic lab=VDD3V3}
C {symbols/pfet_03v3.sym} 2510 -600 0 1 {name=M2
L=1u
W=10u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/code_shown.sym} 3840 -1310 0 0 {name=MODELS only_toplevel=true
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice res_typical
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
* .lib $::180MCU_MODELS/sm141064.ngspice res_statistical
"}
C {devices/code_shown.sym} 3850 -1160 0 0 {name=NGSPICE only_toplevel=true
value="
.control
save all
op 
print v(voutp) 
print v(voutn)
print v(voutp_buff)
print v(voutn_buff)
.endc 
"}
C {vsource.sym} 1650 -1380 0 0 {name=V5 value=0.94 savecurrent=false}
C {devices/code_shown.sym} 3860 -920 0 0 {name=NGSPICE_ac only_toplevel=true
value="
.control
  * 1. Corremos la simulación AC hasta 10 GHz
  ac dec 20 1 10g
  
  * 2. Definición de la salida diferencial y creación del vector en dB
  let vout = v(voutp) - v(voutn)
  let vout_db = db(vout)

  * 3. Cálculo de la ganancia DC y el objetivo de -3 dB
  let dc_gain_db = vout_db[0]
  let target_3db = dc_gain_db - 3.0
  
  echo "=================================================="
  print dc_gain_db
  print target_3db
  echo "=================================================="

  * ==================================================
  * EL TRUCO MAESTRO:
  * Convertimos el número a una variable de entorno de texto (string)
  * ==================================================
  set val_3db = $&target_3db

  * 4. Comandos de medición usando la variable de texto y fall=1
  meas ac f_3db when vout_db=$val_3db fall=1
  meas ac gbw_0db when vout_db=0 fall=1
  
  * ==================================================

  * 5. Graficar la Magnitud en dB
  plot vout_db

  * 6. Phase Margin calculation
  let voutph = (180/(2*PI))*unwrap(ph(vout))
  plot voutph
  meas ac phase_gbw find voutph when vout_db=0 fall=1
  let phase_margin = 180 + phase_gbw
  print phase_gbw
  print phase_margin
.endc
"}
C {lab_pin.sym} 2090 -600 0 0 {name=p14 sig_type=std_logic lab=vp}
C {vsource.sym} 1490 -1380 0 0 {name=V6 value=1.3 savecurrent=false}
C {vsource.sym} 1340 -900 0 0 {name=V8 value="dc 1.65" savecurrent=false}
C {vsource.sym} 1270 -1000 0 0 {name=V10 value="ac 0.5 0" savecurrent=false}
C {vsource.sym} 1410 -1000 0 0 {name=V11 value="ac 0.5 180" savecurrent=false}
C {lab_pin.sym} 2960 -760 0 0 {name=p16 sig_type=std_logic lab=Vbcascp}
C {symbols/nfet_03v3.sym} 2850 -640 0 1 {name=M6
L=1u
W=4u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3060 -640 0 0 {name=M7
L=1u
W=4u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2850 -830 0 1 {name=M8
L=1u
W=4u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3060 -830 0 0 {name=M9
L=1u
W=4u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2300 -750 0 0 {name=M3
L=1u
W=32u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2250 -750 0 0 {name=p8 sig_type=std_logic lab=Vbtail}
C {symbols/nfet_03v3.sym} 2850 -320 0 1 {name=M4
L=1u
W=9u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3060 -320 0 0 {name=M5
L=1u
W=9u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2850 -990 0 1 {name=M10
L=1u
W=4u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3060 -990 0 0 {name=M11
L=1u
W=4u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2960 -950 0 0 {name=p25 sig_type=std_logic lab=Vbfb}
C {lab_pin.sym} 1490 -1470 0 0 {name=p24 sig_type=std_logic lab=Vbcascp}
C {lab_pin.sym} 2960 -600 0 0 {name=p19 sig_type=std_logic lab=Vbcascn}
C {lab_pin.sym} 1650 -1470 0 0 {name=p12 sig_type=std_logic lab=Vbcascn}
C {lab_pin.sym} 2960 -280 0 0 {name=p11 sig_type=std_logic lab=Vbsnk}
C {lab_pin.sym} 3120 -720 0 1 {name=p7 sig_type=std_logic lab=voutp}
C {lab_pin.sym} 2800 -720 0 0 {name=p3 sig_type=std_logic lab=voutn}
C {lab_pin.sym} 2340 -1610 0 0 {name=p31 sig_type=std_logic lab=Ib}
C {lab_pin.sym} 2380 -1740 0 0 {name=p29 sig_type=std_logic lab=voutp}
C {lab_pin.sym} 2400 -2050 0 0 {name=p18 sig_type=std_logic lab=VDD3V3}
C {lab_pin.sym} 1190 -930 0 0 {name=p22 sig_type=std_logic lab=Vref}
C {symbols/pfet_03v3.sym} 2460 -1960 0 0 {name=M20
L=1u
W=3u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2460 -1740 0 0 {name=M21
L=1u
W=10u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2780 -1740 0 1 {name=M22
L=1u
W=10u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2600 -1480 0 0 {name=M23
L=1u
W=8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3020 -1740 0 0 {name=M24
L=1u
W=10u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3340 -1740 0 1 {name=M25
L=1u
W=10u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3160 -1480 0 0 {name=M26
L=1u
W=8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2620 -1740 0 1 {name=p28 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3170 -1740 0 0 {name=p36 sig_type=std_logic lab=VSS}
C {symbols/nfet_03v3.sym} 2360 -1480 0 1 {name=M27
L=1u
W=8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3420 -1740 0 1 {name=p23 sig_type=std_logic lab=voutn}
C {lab_wire.sym} 1020 -1020 0 1 {name=p15 sig_type=std_logic lab=VSS}
C {vsource.sym} 1020 -930 0 0 {name=V2 value=0 savecurrent=false}
C {lab_pin.sym} 2910 -1710 0 0 {name=p17 sig_type=std_logic lab=Vref}
C {isource.sym} 620 -1470 0 0 {name=I1 value=1u}
C {lab_pin.sym} 620 -1570 0 0 {name=p30 sig_type=std_logic lab=VDD3V3}
C {symbols/nfet_03v3.sym} 640 -1350 0 1 {name=M12
L=1u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 810 -1350 0 0 {name=M13
L=1u
W=3u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 850 -1460 0 1 {name=M14
L=1u
W=6u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1060 -1350 0 0 {name=M15
L=1u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1060 -1460 0 0 {name=M16
L=1u
W=11u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2830 -1960 0 0 {name=p13 sig_type=std_logic lab=Vbfb}
C {symbols/pfet_03v3.sym} 3300 -1980 0 0 {name=M17
L=1u
W=3u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2890 -1960 0 0 {name=M18
L=1u
W=3u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1270 -1460 0 0 {name=M28
L=1u
W=4.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2260 -1390 0 0 {name=p33 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2960 -170 0 1 {name=p34 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1340 -830 0 1 {name=p38 sig_type=std_logic lab=VSS}
C {capa.sym} 3490 -750 0 0 {name=C1
m=1
value=20p
footprint=1206
device="ceramic capacitor"}
C {lab_wire.sym} 3540 -660 0 1 {name=p41 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 620 -1270 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 890 -860 0 1 {name=p42 sig_type=std_logic lab=VSS}
C {capa.sym} 3580 -750 0 0 {name=C2
m=1
value=20p
footprint=1206
device="ceramic capacitor"}
C {gnd.sym} 1020 -860 0 0 {name=l1 lab=0}
C {lab_wire.sym} 1490 -1310 0 1 {name=p32 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1650 -1310 0 1 {name=p43 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 5850 -1560 0 0 {name=p48 sig_type=std_logic lab=voutn}
C {lab_pin.sym} 6320 -1640 0 1 {name=p50 sig_type=std_logic lab=voutn_buff}
C {vsource.sym} 4310 -1790 0 0 {name=V3 value=2.6289 savecurrent=false}
C {lab_wire.sym} 4310 -1720 0 1 {name=p52 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 4310 -1880 0 1 {name=p51 sig_type=std_logic lab=Vb_ota}
C {lab_pin.sym} 3490 -800 0 0 {name=p39 sig_type=std_logic lab=voutp_buff}
C {lab_pin.sym} 3580 -800 0 1 {name=p40 sig_type=std_logic lab=voutn_buff}
C {symbols/pfet_03v3.sym} 5190 -970 0 1 {name=M19
L=1u
W=14u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 5390 -970 0 0 {name=M29
L=1u
W=14u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5150 -820 0 0 {name=M30
L=1u
W=50u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5430 -820 0 1 {name=M31
L=1u
W=50u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {isource.sym} 5300 -680 0 0 {name=I2 value=0.5556m}
C {lab_wire.sym} 5300 -620 0 1 {name=p53 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 5290 -1090 0 0 {name=p54 sig_type=std_logic lab=VDD3V3}
C {symbols/pfet_03v3.sym} 5990 -960 0 1 {name=M32
L=1u
W=14u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 6190 -960 0 0 {name=M33
L=1u
W=14u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5950 -810 0 0 {name=M34
L=1u
W=50u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 6230 -810 0 1 {name=M35
L=1u
W=50u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {isource.sym} 6100 -670 0 0 {name=I3 value=0.5556m}
C {lab_wire.sym} 6100 -610 0 1 {name=p57 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 6090 -1080 0 0 {name=p58 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 6100 -830 0 1 {name=p55 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 5300 -850 0 1 {name=p56 sig_type=std_logic lab=VSS}
C {isource.sym} 600 -1920 0 0 {name=I4 value=1u}
C {lab_pin.sym} 600 -2020 0 0 {name=p44 sig_type=std_logic lab=VDD3V3}
C {symbols/nfet_03v3.sym} 620 -1800 0 1 {name=M36
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 790 -1800 0 0 {name=M37
L=2u
W=2u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 830 -1910 0 1 {name=M38
L=2u
W=2u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 940 -1910 1 1 {name=p45 sig_type=std_logic lab=Vbtail}
C {symbols/nfet_03v3.sym} 1040 -1800 0 0 {name=M39
L=2u
W=2u
nf=1
m=4
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1040 -1910 0 0 {name=M40
L=2u
W=2u
nf=1
m=11
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 980 -1800 0 0 {name=p46 sig_type=std_logic lab=Vbsnk}
C {lab_pin.sym} 720 -1780 0 0 {name=p59 sig_type=std_logic lab=Vbias}
C {symbols/pfet_03v3.sym} 1250 -1910 0 0 {name=M41
L=2u
W=6.8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1190 -1910 1 1 {name=p60 sig_type=std_logic lab=Vbtail}
C {lab_pin.sym} 1270 -1810 0 0 {name=p61 sig_type=std_logic lab=Ib}
C {lab_wire.sym} 600 -1720 0 0 {name=p62 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 5090 -1570 0 0 {name=p20 sig_type=std_logic lab=voutp}
C {lab_pin.sym} 5560 -1650 0 1 {name=p26 sig_type=std_logic lab=voutp_buff}
C {symbols/pfet_03v3.sym} 5190 -1720 0 1 {name=M42
L=2u
W=2u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 5390 -1720 0 0 {name=M43
L=2u
W=2u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5150 -1570 0 0 {name=M44
L=2u
W=2u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5430 -1570 0 1 {name=M45
L=2u
W=2u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 5300 -1370 0 1 {name=p27 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 5290 -1840 0 0 {name=p35 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 5300 -1600 0 1 {name=p37 sig_type=std_logic lab=VSS}
C {symbols/nfet_03v3.sym} 5280 -1430 0 0 {name=M46
L=2u
W=2u
nf=1
m=10
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 5200 -1430 0 0 {name=p63 sig_type=std_logic lab=Vbias}
C {symbols/pfet_03v3.sym} 5950 -1710 0 1 {name=M47
L=2u
W=2u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 6150 -1710 0 0 {name=M48
L=2u
W=2u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5910 -1560 0 0 {name=M49
L=2u
W=2u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 6190 -1560 0 1 {name=M50
L=2u
W=2u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 6060 -1360 0 1 {name=p66 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 6050 -1830 0 0 {name=p67 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 6060 -1590 0 1 {name=p68 sig_type=std_logic lab=VSS}
C {symbols/nfet_03v3.sym} 6040 -1420 0 0 {name=M51
L=2u
W=2u
nf=1
m=10
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 5960 -1420 0 0 {name=p69 sig_type=std_logic lab=Vbias}
C {lab_pin.sym} 7310 -1570 0 0 {name=p47 sig_type=std_logic lab=vin_tran}
C {lab_pin.sym} 7780 -1650 0 1 {name=p49 sig_type=std_logic lab=vout_tran}
C {symbols/pfet_03v3.sym} 7410 -1720 0 1 {name=M52
L=2u
W=2u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 7610 -1720 0 0 {name=M53
L=2u
W=2u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 7370 -1570 0 0 {name=M54
L=2u
W=2u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 7650 -1570 0 1 {name=M55
L=2u
W=2u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 7520 -1370 0 1 {name=p64 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 7510 -1840 0 0 {name=p65 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 7520 -1600 0 1 {name=p70 sig_type=std_logic lab=VSS}
C {symbols/nfet_03v3.sym} 7500 -1430 0 0 {name=M56
L=2u
W=2u
nf=1
m=10
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {vsource.sym} 6930 -1480 0 0 {name=V4 value="SIN(1.65 0.5 3MEG 0 0)" savecurrent=false}
C {lab_wire.sym} 6930 -1410 0 1 {name=p72 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 6930 -1570 0 1 {name=p73 sig_type=std_logic lab=vin_tran}
C {lab_pin.sym} 7420 -1430 0 0 {name=p74 sig_type=std_logic lab=Vbias}
C {vsource.sym} 1270 -650 0 1 {name=Vin_p value="SIN(1.65 100u 1k 0 0 0)" savecurrent=false}
C {vsource.sym} 1410 -650 0 0 {name=Vin_n value="SIN(1.65 100u 1k 0 0 180)" savecurrent=false}
C {lab_pin.sym} 1270 -740 0 0 {name=p71 sig_type=std_logic lab=vp}
C {lab_pin.sym} 1410 -740 0 1 {name=p75 sig_type=std_logic lab=vn}
C {lab_wire.sym} 1340 -540 0 1 {name=p76 sig_type=std_logic lab=VSS}
C {devices/code_shown.sym} 4455.119489031288 -1280 0 0 {name=NGSPICE2 only_toplevel=true
value="
.tran 1n 100u

.control
  run
  save all
  plot v(vout_tran) v(vin_tran)
  plot v(voutp_buff) v(voutn_buff)
.endc
"}
