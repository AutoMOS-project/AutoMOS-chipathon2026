v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 2470 -1970 2470 -1920 {lab=VDD3V3}
N 2470 -1860 2470 -1800 {lab=1ua}
N 2340 -1840 2340 -1800 {lab=VSS}
N 2340 -1960 2340 -1900 {lab=Vbcn}
N 2180 -1840 2180 -1800 {lab=VSS}
N 2180 -1960 2180 -1900 {lab=Vbcp}
N 2050 -1840 2050 -1800 {lab=VSS}
N 2050 -1960 2050 -1900 {lab=VDD3V3}
N 1910 -1850 1910 -1820 {lab=0}
N 1910 -1820 1910 -1810 {lab=0}
N 1910 -1960 1910 -1910 {lab=VSS}
N 4090 -1560 4090 -1510 {lab=VSS}
N 2010 -1360 2010 -1320 {lab=VSS}
N 2150 -1360 2150 -1320 {lab=VSS}
N 2010 -1320 2150 -1320 {lab=VSS}
N 2010 -1450 2010 -1420 {lab=vp}
N 2150 -1450 2150 -1420 {lab=vn}
N 2230 -1610 2230 -1580 {lab=VSS}
N 2230 -1580 2230 -1570 {lab=VSS}
N 2230 -1720 2230 -1670 {lab=S1}
N 2320 -1610 2320 -1580 {lab=VSS}
N 2320 -1580 2320 -1570 {lab=VSS}
N 2320 -1720 2320 -1670 {lab=S0}
N 3740 -1680 3920 -1680 {lab=#net1}
N 3740 -1640 3920 -1640 {lab=#net2}
N 4070 -1850 4070 -1760 {lab=VDD3V3}
N 4130 -1820 4130 -1760 {lab=Vbcn}
N 4050 -1560 4050 -1510 {lab=Vcm}
N 2430 -1610 2430 -1580 {lab=VSS}
N 2430 -1580 2430 -1570 {lab=VSS}
N 2430 -1720 2430 -1670 {lab=Vcm}
N 5190 -1750 5190 -1730 {lab=voutp}
N 5190 -1460 5190 -1440 {lab=voutn}
N 5190 -1670 5190 -1630 {lab=VSS}
N 5190 -1390 5190 -1340 {lab=VSS}
N 4010 -1820 4010 -1760 {lab=Vbcp}
N 2370 -1360 2370 -1320 {lab=VSS}
N 2370 -1450 2370 -1420 {lab=p1}
N 2150 -1320 2370 -1320 {lab=VSS}
N 4960 -1730 5020 -1730 {lab=1ua}
N 4960 -1760 5020 -1760 {lab=outp}
N 5070 -1700 5070 -1670 {lab=VSS}
N 5070 -1830 5070 -1800 {lab=VDD3V3}
N 5140 -1750 5190 -1750 {lab=voutp}
N 4960 -1440 5020 -1440 {lab=1ua}
N 4960 -1470 5020 -1470 {lab=outn}
N 5070 -1410 5070 -1380 {lab=VSS}
N 5070 -1540 5070 -1510 {lab=VDD3V3}
N 5140 -1460 5190 -1460 {lab=voutn}
N 4030 -3030 4030 -3010 {lab=p1b}
N 4050 -3030 4050 -3010 {lab=p1}
N 4070 -3030 4070 -3010 {lab=VDD3V3}
N 4070 -3030 4100 -3030 {lab=VDD3V3}
N 4050 -2910 4050 -2890 {lab=VSS}
N 4030 -2260 4030 -2240 {lab=S1B}
N 4050 -2260 4050 -2240 {lab=S1}
N 4070 -2260 4070 -2240 {lab=VDD3V3}
N 4070 -2260 4100 -2260 {lab=VDD3V3}
N 4050 -2140 4050 -2120 {lab=VSS}
N 4030 -2070 4030 -2050 {lab=S0B}
N 4050 -2070 4050 -2050 {lab=S0}
N 4070 -2070 4070 -2050 {lab=VDD3V3}
N 4070 -2070 4100 -2070 {lab=VDD3V3}
N 4050 -1950 4050 -1930 {lab=VSS}
N 4120 -2000 4180 -2000 {lab=#net3}
N 3500 -1680 3680 -1680 {lab=vp}
N 3500 -1640 3680 -1640 {lab=vn}
N 3920 -1600 3920 -1510 {lab=1ua}
N 3070 -1470 3070 -1440 {lab=VDD3V3}
N 3070 -1360 3070 -1330 {lab=VSS}
N 2990 -1400 3020 -1400 {lab=p1}
N 3140 -1400 3170 -1400 {lab=p1b}
N 2750 -1690 2750 -1660 {lab=VDD3V3}
N 2750 -1580 2750 -1550 {lab=VSS}
N 2670 -1620 2700 -1620 {lab=S2}
N 2820 -1620 2850 -1620 {lab=S2B}
N 2750 -1890 2750 -1860 {lab=VDD3V3}
N 2750 -1780 2750 -1750 {lab=VSS}
N 2670 -1820 2700 -1820 {lab=S0}
N 2820 -1820 2850 -1820 {lab=S0B}
N 4030 -2450 4030 -2430 {lab=S2B}
N 4050 -2450 4050 -2430 {lab=S2}
N 4070 -2450 4070 -2430 {lab=VDD3V3}
N 4070 -2450 4100 -2450 {lab=VDD3V3}
N 4050 -2330 4050 -2310 {lab=VSS}
N 4120 -2380 4180 -2380 {lab=#net4}
N 4030 -2650 4030 -2630 {lab=S3B}
N 4050 -2650 4050 -2630 {lab=S3}
N 4070 -2650 4070 -2630 {lab=VDD3V3}
N 4070 -2650 4100 -2650 {lab=VDD3V3}
N 4050 -2530 4050 -2510 {lab=VSS}
N 4120 -2580 4180 -2580 {lab=#net5}
N 4030 -2840 4030 -2820 {lab=S4B}
N 4050 -2840 4050 -2820 {lab=S4}
N 4070 -2840 4070 -2820 {lab=VDD3V3}
N 4070 -2840 4100 -2840 {lab=VDD3V3}
N 4050 -2720 4050 -2700 {lab=VSS}
N 4120 -2770 4180 -2770 {lab=#net6}
N 3810 -2000 3980 -2000 {lab=#net1}
N 4240 -2000 4410 -2000 {lab=outn}
N 4220 -1640 4410 -1640 {lab=outn}
N 4240 -2380 4410 -2380 {lab=outn}
N 3810 -2380 3980 -2380 {lab=#net1}
N 4240 -2580 4410 -2580 {lab=outn}
N 3810 -2580 3980 -2580 {lab=#net1}
N 4240 -2770 4410 -2770 {lab=outn}
N 3810 -2770 3980 -2770 {lab=#net1}
N 3810 -2190 3810 -2000 {lab=#net1}
N 3810 -2380 3810 -2190 {lab=#net1}
N 3810 -2580 3810 -2380 {lab=#net1}
N 3810 -2770 3810 -2580 {lab=#net1}
N 4410 -2190 4410 -2000 {lab=outn}
N 4410 -2380 4410 -2190 {lab=outn}
N 4410 -2580 4410 -2380 {lab=outn}
N 4410 -2770 4410 -2580 {lab=outn}
N 4410 -2000 4410 -1640 {lab=outn}
N 3810 -2000 3810 -1680 {lab=#net1}
N 4030 -1080 4030 -1060 {lab=S1B}
N 4050 -1080 4050 -1060 {lab=S1}
N 4070 -1080 4070 -1060 {lab=VDD3V3}
N 4070 -1060 4100 -1060 {lab=VDD3V3}
N 4050 -1200 4050 -1180 {lab=VSS}
N 4030 -1270 4030 -1250 {lab=S0B}
N 4050 -1270 4050 -1250 {lab=S0}
N 4070 -1270 4070 -1250 {lab=VDD3V3}
N 4070 -1250 4100 -1250 {lab=VDD3V3}
N 4050 -1390 4050 -1370 {lab=VSS}
N 4120 -1320 4180 -1320 {lab=#net7}
N 4030 -890 4030 -870 {lab=S2B}
N 4050 -890 4050 -870 {lab=S2}
N 4070 -890 4070 -870 {lab=VDD3V3}
N 4070 -870 4100 -870 {lab=VDD3V3}
N 4050 -1010 4050 -990 {lab=VSS}
N 4120 -940 4180 -940 {lab=#net8}
N 4030 -690 4030 -670 {lab=S3B}
N 4050 -690 4050 -670 {lab=S3}
N 4070 -690 4070 -670 {lab=VDD3V3}
N 4070 -670 4100 -670 {lab=VDD3V3}
N 4050 -810 4050 -790 {lab=VSS}
N 4120 -740 4180 -740 {lab=#net9}
N 4030 -500 4030 -480 {lab=S4B}
N 4050 -500 4050 -480 {lab=S4}
N 4070 -500 4070 -480 {lab=VDD3V3}
N 4070 -480 4100 -480 {lab=VDD3V3}
N 4050 -620 4050 -600 {lab=VSS}
N 4120 -550 4180 -550 {lab=#net10}
N 3810 -1320 3980 -1320 {lab=#net2}
N 4240 -1320 4410 -1320 {lab=outp}
N 4240 -940 4410 -940 {lab=outp}
N 3810 -940 3980 -940 {lab=#net2}
N 4240 -740 4410 -740 {lab=outp}
N 3810 -740 3980 -740 {lab=#net2}
N 4240 -550 4410 -550 {lab=outp}
N 3810 -550 3980 -550 {lab=#net2}
N 3810 -1320 3810 -1130 {lab=#net2}
N 3810 -1130 3810 -940 {lab=#net2}
N 3810 -940 3810 -740 {lab=#net2}
N 3810 -740 3810 -550 {lab=#net2}
N 4410 -1320 4410 -1130 {lab=outp}
N 4410 -1130 4410 -940 {lab=outp}
N 4410 -940 4410 -740 {lab=outp}
N 4410 -740 4410 -550 {lab=outp}
N 3810 -1640 3810 -1320 {lab=#net2}
N 4320 -1680 4320 -1320 {lab=outp}
N 4220 -1680 4320 -1680 {lab=outp}
N 4320 -1680 4550 -1680 {lab=outp}
N 4410 -1640 4550 -1640 {lab=outn}
N 3810 -2960 3810 -2770 {lab=#net1}
N 3810 -2960 3980 -2960 {lab=#net1}
N 4410 -2960 4410 -2770 {lab=outn}
N 4120 -2960 4410 -2960 {lab=outn}
N 4030 -310 4030 -290 {lab=p1b}
N 4050 -310 4050 -290 {lab=p1}
N 4070 -310 4070 -290 {lab=VDD3V3}
N 4070 -290 4100 -290 {lab=VDD3V3}
N 4050 -430 4050 -410 {lab=VSS}
N 3810 -360 3980 -360 {lab=#net2}
N 4120 -360 4410 -360 {lab=outp}
N 3810 -550 3810 -360 {lab=#net2}
N 4410 -550 4410 -360 {lab=outp}
N 3070 -1890 3070 -1860 {lab=VDD3V3}
N 3070 -1780 3070 -1750 {lab=VSS}
N 2990 -1820 3020 -1820 {lab=S1}
N 3140 -1820 3170 -1820 {lab=S1B}
N 3070 -1690 3070 -1660 {lab=VDD3V3}
N 3070 -1580 3070 -1550 {lab=VSS}
N 2990 -1620 3020 -1620 {lab=S3}
N 3140 -1620 3170 -1620 {lab=S3B}
N 2760 -1460 2760 -1430 {lab=VDD3V3}
N 2760 -1350 2760 -1320 {lab=VSS}
N 2680 -1390 2710 -1390 {lab=S4}
N 2830 -1390 2860 -1390 {lab=S4B}
N 2060 -1610 2060 -1580 {lab=VSS}
N 2060 -1580 2060 -1570 {lab=VSS}
N 2060 -1720 2060 -1670 {lab=S3}
N 2150 -1610 2150 -1580 {lab=VSS}
N 2150 -1580 2150 -1570 {lab=VSS}
N 2150 -1720 2150 -1670 {lab=S2}
N 1970 -1610 1970 -1580 {lab=VSS}
N 1970 -1580 1970 -1570 {lab=VSS}
N 1970 -1720 1970 -1670 {lab=S4}
N 4120 -1130 4180 -1130 {lab=#net11}
N 4240 -1130 4410 -1130 {lab=outp}
N 3810 -1130 3980 -1130 {lab=#net2}
N 3810 -2190 3980 -2190 {lab=#net1}
N 4120 -2190 4180 -2190 {lab=#net12}
N 4240 -2190 4410 -2190 {lab=outn}
C {isource.sym} 2470 -1890 0 0 {name=I4 value=1u}
C {lab_pin.sym} 2470 -1800 0 0 {name=p61 sig_type=std_logic lab=1ua}
C {vsource.sym} 2340 -1870 0 0 {name=V5 value=0.94 savecurrent=false}
C {vsource.sym} 2180 -1870 0 0 {name=V6 value=1.3 savecurrent=false}
C {lab_pin.sym} 2180 -1960 0 0 {name=p24 sig_type=std_logic lab=Vbcp}
C {lab_pin.sym} 2340 -1960 0 0 {name=p12 sig_type=std_logic lab=Vbcn}
C {lab_wire.sym} 2180 -1800 0 1 {name=p32 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2340 -1800 0 1 {name=p43 sig_type=std_logic lab=VSS}
C {vsource.sym} 2050 -1870 0 0 {name=V1 value=3.3 savecurrent=false}
C {lab_pin.sym} 2050 -1960 0 0 {name=p5 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 1910 -1960 0 0 {name=p15 sig_type=std_logic lab=VSS}
C {vsource.sym} 1910 -1880 0 0 {name=V2 value=0 savecurrent=false}
C {lab_wire.sym} 2050 -1800 0 1 {name=p42 sig_type=std_logic lab=VSS}
C {gnd.sym} 1910 -1810 0 0 {name=l1 lab=0}
C {lab_pin.sym} 2470 -1970 0 0 {name=p1 sig_type=std_logic lab=VDD3V3}
C {lab_pin.sym} 3920 -1510 0 1 {name=p2 sig_type=std_logic lab=1ua}
C {lab_wire.sym} 4090 -1510 0 1 {name=p3 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 4070 -1850 0 1 {name=p4 sig_type=std_logic lab=VDD3V3}
C {lab_pin.sym} 4550 -1680 0 1 {name=p11 sig_type=std_logic lab=outp}
C {lab_pin.sym} 4550 -1640 0 1 {name=p13 sig_type=std_logic lab=outn}
C {lab_wire.sym} 3500 -1680 0 0 {name=p14 sig_type=std_logic lab=vp}
C {lab_wire.sym} 3500 -1640 0 0 {name=p16 sig_type=std_logic lab=vn}
C {lab_pin.sym} 2010 -1450 0 0 {name=p71 sig_type=std_logic lab=vp}
C {lab_pin.sym} 2150 -1450 0 1 {name=p75 sig_type=std_logic lab=vn}
C {vsource.sym} 2010 -1390 0 1 {name=Vin_p value="SIN(1.65 1m 100 0 0 0)" savecurrent=false}
C {vsource.sym} 2150 -1390 0 0 {name=Vin_n value="SIN(1.65 1m 100 0 0 180)" savecurrent=false}
C {lab_wire.sym} 2070 -1320 0 1 {name=p80 sig_type=std_logic lab=VSS}
C {devices/code_shown.sym} 1235.119489031288 -1630 0 0 {name=NGSPICE2 only_toplevel=true
value="
.tran 1u 25m

.control
  run
  save all
  plot v(vp) v(vn)
  plot v(vp)-v(vn)
  plot v(outp)-v(outn)
  plot v(outp) v(outn)
  plot v(voutp)-v(voutn)
.endc
"}
C {lab_wire.sym} 4050 -2260 0 1 {name=p39 sig_type=std_logic lab=S1}
C {lab_wire.sym} 4030 -2260 0 0 {name=p44 sig_type=std_logic lab=S1B}
C {lab_wire.sym} 4050 -2070 0 1 {name=p45 sig_type=std_logic lab=S0}
C {lab_wire.sym} 4030 -2070 0 0 {name=p46 sig_type=std_logic lab=S0B}
C {lab_wire.sym} 2850 -1620 0 1 {name=p65 sig_type=std_logic lab=S2B}
C {lab_wire.sym} 2230 -1570 0 0 {name=p66 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2670 -1620 0 0 {name=p67 sig_type=std_logic lab=S2}
C {vsource.sym} 1970 -1640 0 0 {name=V8 value=3.3 savecurrent=false}
C {lab_wire.sym} 2320 -1570 0 0 {name=p70 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2320 -1720 0 0 {name=p72 sig_type=std_logic lab=S0}
C {lab_wire.sym} 4050 -1510 0 0 {name=p73 sig_type=std_logic lab=Vcm}
C {lab_wire.sym} 2430 -1720 0 0 {name=p74 sig_type=std_logic lab=Vcm}
C {lab_wire.sym} 2430 -1570 0 0 {name=p76 sig_type=std_logic lab=VSS}
C {vsource.sym} 2430 -1640 0 0 {name=V10 value=1.65 savecurrent=false}
C {lab_pin.sym} 4010 -1820 0 0 {name=p77 sig_type=std_logic lab=Vbcp}
C {lab_pin.sym} 4130 -1820 0 1 {name=p6 sig_type=std_logic lab=Vbcn}
C {devices/code_shown.sym} 1080 -1900 0 0 {name=MODELS only_toplevel=true
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice res_typical
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_typical
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
* .lib $::180MCU_MODELS/sm141064.ngspice res_statistical
"}
C {capa.sym} 5190 -1700 0 0 {name=C7
m=1
value=20p
footprint=1206
device="ceramic capacitor"}
C {lab_wire.sym} 5190 -1630 0 1 {name=p7 sig_type=std_logic lab=VSS}
C {capa.sym} 5190 -1410 0 0 {name=C9
m=1
value=20p
footprint=1206
device="ceramic capacitor"}
C {vsource.sym} 2060 -1640 0 0 {name=V3 value=0 savecurrent=false}
C {lab_pin.sym} 4100 -3030 0 1 {name=p8 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 4050 -2890 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4050 -3030 0 1 {name=p31 sig_type=std_logic lab=p1}
C {lab_wire.sym} 4030 -3030 0 0 {name=p33 sig_type=std_logic lab=p1b}
C {lab_pin.sym} 2370 -1450 0 1 {name=p62 sig_type=std_logic lab=p1}
C {vsource.sym} 2370 -1390 0 0 {name=Vclk2 value="PULSE(0 3.3 0 10n 10n 10u 1)" savecurrent=false}
C {lab_wire.sym} 5070 -1670 0 0 {name=p41 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 5070 -1830 0 0 {name=p10 sig_type=std_logic lab=VDD3V3}
C {lab_pin.sym} 5190 -1460 0 1 {name=p56 sig_type=std_logic lab=voutn}
C {lab_pin.sym} 5190 -1750 0 1 {name=p36 sig_type=std_logic lab=voutp}
C {lab_pin.sym} 4960 -1730 0 0 {name=p37 sig_type=std_logic lab=1ua}
C {lab_pin.sym} 4960 -1470 0 0 {name=p58 sig_type=std_logic lab=outn}
C {lab_pin.sym} 4960 -1760 0 0 {name=p38 sig_type=std_logic lab=outp}
C {lab_wire.sym} 5070 -1380 0 0 {name=p52 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 5070 -1540 0 0 {name=p53 sig_type=std_logic lab=VDD3V3}
C {lab_pin.sym} 4960 -1440 0 0 {name=p55 sig_type=std_logic lab=1ua}
C {lab_wire.sym} 5190 -1340 0 1 {name=p19 sig_type=std_logic lab=VSS}
C {/foss/designs/core_pga/folded_cascode/folded_cascode_v3.sym} 4070 -1660 0 0 {name=x1}
C {/foss/designs/core_pga/buffer/core_buffer.sym} 5020 -1700 0 0 {name=x2}
C {/foss/designs/core_pga/buffer/core_buffer.sym} 5020 -1410 0 0 {name=x3}
C {/foss/designs/core_pga/switch/switch.sym} 3980 -2910 0 0 {name=x4}
C {lab_pin.sym} 4100 -2260 0 1 {name=p34 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 4050 -2120 0 0 {name=p35 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 4100 -2070 0 1 {name=p40 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 4050 -1930 0 0 {name=p51 sig_type=std_logic lab=VSS}
C {/foss/designs/core_pga/switch/switch.sym} 3980 -1950 0 0 {name=x6}
C {lab_pin.sym} 3070 -1470 0 0 {name=p47 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 3070 -1330 0 0 {name=p48 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2990 -1400 0 0 {name=p49 sig_type=std_logic lab=p1}
C {lab_wire.sym} 2230 -1720 0 0 {name=p50 sig_type=std_logic lab=S1}
C {lab_wire.sym} 2850 -1820 0 1 {name=p59 sig_type=std_logic lab=S0B}
C {lab_wire.sym} 2670 -1820 0 0 {name=p60 sig_type=std_logic lab=S0}
C {/foss/designs/core_pga/inverter/inverter.sym} 3020 -1360 0 0 {name=x10}
C {lab_pin.sym} 3170 -1400 0 1 {name=p68 sig_type=std_logic lab=p1b}
C {lab_pin.sym} 2750 -1690 0 0 {name=p63 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 2750 -1550 0 0 {name=p69 sig_type=std_logic lab=VSS}
C {/foss/designs/core_pga/inverter/inverter.sym} 2700 -1580 0 0 {name=x11}
C {lab_pin.sym} 2750 -1890 0 0 {name=p79 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 2750 -1750 0 0 {name=p81 sig_type=std_logic lab=VSS}
C {/foss/designs/core_pga/inverter/inverter.sym} 2700 -1780 0 0 {name=x12}
C {lab_wire.sym} 4050 -2450 0 1 {name=p54 sig_type=std_logic lab=S2}
C {lab_wire.sym} 4030 -2450 0 0 {name=p57 sig_type=std_logic lab=S2B}
C {lab_pin.sym} 4100 -2450 0 1 {name=p64 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 4050 -2310 0 0 {name=p78 sig_type=std_logic lab=VSS}
C {/foss/designs/core_pga/switch/switch.sym} 3980 -2330 0 0 {name=x13}
C {lab_wire.sym} 4050 -2650 0 1 {name=p82 sig_type=std_logic lab=S3}
C {lab_wire.sym} 4030 -2650 0 0 {name=p83 sig_type=std_logic lab=S3B}
C {lab_pin.sym} 4100 -2650 0 1 {name=p84 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 4050 -2510 0 0 {name=p85 sig_type=std_logic lab=VSS}
C {/foss/designs/core_pga/switch/switch.sym} 3980 -2530 0 0 {name=x14}
C {lab_wire.sym} 4050 -2840 0 1 {name=p86 sig_type=std_logic lab=S4}
C {lab_wire.sym} 4030 -2840 0 0 {name=p87 sig_type=std_logic lab=S4B}
C {lab_pin.sym} 4100 -2840 0 1 {name=p88 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 4050 -2700 0 0 {name=p89 sig_type=std_logic lab=VSS}
C {/foss/designs/core_pga/switch/switch.sym} 3980 -2720 0 0 {name=x15}
C {lab_wire.sym} 4050 -1060 2 0 {name=p17 sig_type=std_logic lab=S1}
C {lab_wire.sym} 4030 -1060 2 1 {name=p18 sig_type=std_logic lab=S1B}
C {lab_wire.sym} 4050 -1250 2 0 {name=p20 sig_type=std_logic lab=S0}
C {lab_wire.sym} 4030 -1250 2 1 {name=p21 sig_type=std_logic lab=S0B}
C {lab_pin.sym} 4100 -1060 2 0 {name=p22 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 4050 -1200 2 1 {name=p23 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 4100 -1250 2 0 {name=p25 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 4050 -1390 2 1 {name=p26 sig_type=std_logic lab=VSS}
C {/foss/designs/core_pga/switch/switch.sym} 3980 -1370 2 1 {name=x8}
C {lab_wire.sym} 4050 -870 2 0 {name=p27 sig_type=std_logic lab=S2}
C {lab_wire.sym} 4030 -870 2 1 {name=p28 sig_type=std_logic lab=S2B}
C {lab_pin.sym} 4100 -870 2 0 {name=p29 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 4050 -1010 2 1 {name=p30 sig_type=std_logic lab=VSS}
C {/foss/designs/core_pga/switch/switch.sym} 3980 -990 2 1 {name=x9}
C {lab_wire.sym} 4050 -670 2 0 {name=p90 sig_type=std_logic lab=S3}
C {lab_wire.sym} 4030 -670 2 1 {name=p91 sig_type=std_logic lab=S3B}
C {lab_pin.sym} 4100 -670 2 0 {name=p92 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 4050 -810 2 1 {name=p93 sig_type=std_logic lab=VSS}
C {/foss/designs/core_pga/switch/switch.sym} 3980 -790 2 1 {name=x16}
C {lab_wire.sym} 4050 -480 2 0 {name=p94 sig_type=std_logic lab=S4}
C {lab_wire.sym} 4030 -480 2 1 {name=p95 sig_type=std_logic lab=S4B}
C {lab_pin.sym} 4100 -480 2 0 {name=p96 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 4050 -620 2 1 {name=p97 sig_type=std_logic lab=VSS}
C {/foss/designs/core_pga/switch/switch.sym} 3980 -600 2 1 {name=x17}
C {lab_pin.sym} 4100 -290 2 0 {name=p98 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 4050 -430 2 1 {name=p99 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4050 -290 2 0 {name=p100 sig_type=std_logic lab=p1}
C {lab_wire.sym} 4030 -290 2 1 {name=p101 sig_type=std_logic lab=p1b}
C {/foss/designs/core_pga/switch/switch.sym} 3980 -410 2 1 {name=x18}
C {lab_wire.sym} 3170 -1820 0 1 {name=p102 sig_type=std_logic lab=S1B}
C {lab_wire.sym} 2990 -1820 0 0 {name=p103 sig_type=std_logic lab=S1}
C {lab_pin.sym} 3070 -1890 0 0 {name=p104 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 3070 -1750 0 0 {name=p105 sig_type=std_logic lab=VSS}
C {/foss/designs/core_pga/inverter/inverter.sym} 3020 -1780 0 0 {name=x19}
C {lab_wire.sym} 3170 -1620 0 1 {name=p106 sig_type=std_logic lab=S3B}
C {lab_wire.sym} 2990 -1620 0 0 {name=p107 sig_type=std_logic lab=S3}
C {lab_pin.sym} 3070 -1690 0 0 {name=p108 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 3070 -1550 0 0 {name=p109 sig_type=std_logic lab=VSS}
C {/foss/designs/core_pga/inverter/inverter.sym} 3020 -1580 0 0 {name=x20}
C {lab_wire.sym} 2860 -1390 0 1 {name=p110 sig_type=std_logic lab=S4B}
C {lab_wire.sym} 2680 -1390 0 0 {name=p111 sig_type=std_logic lab=S4}
C {lab_pin.sym} 2760 -1460 0 0 {name=p112 sig_type=std_logic lab=VDD3V3}
C {lab_wire.sym} 2760 -1320 0 0 {name=p113 sig_type=std_logic lab=VSS}
C {/foss/designs/core_pga/inverter/inverter.sym} 2710 -1350 0 0 {name=x21}
C {lab_wire.sym} 2060 -1570 0 0 {name=p114 sig_type=std_logic lab=VSS}
C {vsource.sym} 2320 -1640 0 0 {name=V4 value=0 savecurrent=false}
C {lab_wire.sym} 2150 -1570 0 0 {name=p115 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2150 -1720 0 0 {name=p116 sig_type=std_logic lab=S2}
C {vsource.sym} 2230 -1640 0 0 {name=V7 value=0 savecurrent=false}
C {lab_wire.sym} 2060 -1720 0 0 {name=p117 sig_type=std_logic lab=S3}
C {lab_wire.sym} 1970 -1570 0 0 {name=p118 sig_type=std_logic lab=VSS}
C {vsource.sym} 2150 -1640 0 0 {name=V9 value=0 savecurrent=false}
C {lab_wire.sym} 1970 -1720 0 0 {name=p119 sig_type=std_logic lab=S4}
C {symbols/cap_mim_2f0fF.sym} 3710 -1640 1 0 {name=C5
W=11e-6
L=11e-6
model=cap_mim_2f0fF
spiceprefix=X
m=16}
C {symbols/cap_mim_2f0fF.sym} 3710 -1680 1 1 {name=C2
W=11e-6
L=11e-6
model=cap_mim_2f0fF
spiceprefix=X
m=16}
C {symbols/cap_mim_2f0fF.sym} 4210 -1320 1 0 {name=C6
W=11e-6
L=11e-6
model=cap_mim_2f0fF
spiceprefix=X
m=16}
C {symbols/cap_mim_2f0fF.sym} 4210 -2000 1 0 {name=C11
W=11e-6
L=11e-6
model=cap_mim_2f0fF
spiceprefix=X
m=16}
C {symbols/cap_mim_2f0fF.sym} 4210 -940 1 0 {name=C1
W=11e-6
L=11e-6
model=cap_mim_2f0fF
spiceprefix=X
m=4}
C {symbols/cap_mim_2f0fF.sym} 4210 -2380 1 0 {name=C8
W=11e-6
L=11e-6
model=cap_mim_2f0fF
spiceprefix=X
m=4}
C {symbols/cap_mim_2f0fF.sym} 4210 -2580 1 0 {name=C10
W=11e-6
L=11e-6
model=cap_mim_2f0fF
spiceprefix=X
m=2}
C {symbols/cap_mim_2f0fF.sym} 4210 -2770 1 0 {name=C12
W=11e-6
L=11e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {symbols/cap_mim_2f0fF.sym} 4210 -740 1 0 {name=C13
W=11e-6
L=11e-6
model=cap_mim_2f0fF
spiceprefix=X
m=2}
C {symbols/cap_mim_2f0fF.sym} 4210 -550 1 0 {name=C15
W=11e-6
L=11e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {symbols/cap_mim_2f0fF.sym} 4210 -1130 1 0 {name=C4
W=11e-6
L=11e-6
model=cap_mim_2f0fF
spiceprefix=X
m=8}
C {symbols/cap_mim_2f0fF.sym} 4210 -2190 1 0 {name=C3
W=11e-6
L=11e-6
model=cap_mim_2f0fF
spiceprefix=X
m=8}
C {/foss/designs/core_pga/switch/switch.sym} 3980 -1180 2 1 {name=x7}
C {/foss/designs/core_pga/switch/switch.sym} 3980 -2140 0 0 {name=x5}
